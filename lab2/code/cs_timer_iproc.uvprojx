# Keil uVision project cs_timer_iproc.uvprojx, settings and files
target CS Timer IPROC SIM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: cs_timer_irq
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SE350_DEMO_FALSE K_MSG_ENV DEBUG_01 SIM_TARGET TIMER_IPROC TEST_2_MEM_BLK_0
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Documentation
    ./: Abstract.txt
  group System Code
    ./src/: main_svc.c printf.c uart_polling.c
  group Kernel
    ./src/: HAL.c k_memory.c k_msg.c k_process.c k_rtx_init.c k_priority_queue.c ae_util.c k_queue.c k_sys_procs.c
  group Interrupt
    ./src/: timer.c
  group P2-AE6
    ../tests/AE06/: ae_proc_06.c ae06.c
  group P2-AE07
    ../tests/AE07/: ae_proc_07.c ae07.c
  group P2-AE08
    ../tests/AE08/: ae_proc_08.c ae08.c
  group P2-AE09
    ../tests/AE09/: ae_proc_09.c ae09.c
  group P2-AE10
    ../tests/AE10/: ae_proc_10.c ae10.c
  group P2-Tests
    ../../manual_code/Auto_Test/P2/: ae.c ae_proc_3.c ae_proc_4.c ae_proc_11.c ae_proc_t3.c ae_proc_t4.c ae_proc_t6.c ae_timer.c
target CS Timer IPROC RAM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.6.0
  cpu: as above
  output: cs_timer_irq
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: SE350_DEMO_0 K_MSG_ENV DEGUG_0 TIMER_IPROC TEST_2_MEM_BLK_0
  asm define: NO_CRP
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
